options:
  parameters:
    author: Zheng Xudong
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM_Rx
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: 87e6
    step: 50e3
    stop: 108e6
    value: 91.2e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '1'
    stop: '74'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    comment: |-
      “FM调制”
      “输入信号频率=480k”
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: 1024*4
    name: FM_Rx
    showports: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      "重采样"
      “插值=1，抽取=5”
    decim: '5'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '''TX/RX'''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
