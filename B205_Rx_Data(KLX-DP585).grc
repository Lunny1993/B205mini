options:
  parameters:
    generate_options: qt_gui
    id: lime_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: deci
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 400.375e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 400.395e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\63203\Desktop\KLX-V8(4FSK)_IQ-Data_D_0517.bin
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 16e3
    decim: deci
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/deci
    fc: rx_freq
    fftsize: '1024'
    name: '"F0"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rx_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', blocks_file_sink_0_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
